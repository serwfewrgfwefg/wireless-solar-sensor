# Keil uVision project STM32U073_inclinometer  - 4G - V3.3.1.uvprojx, settings and files
target STM32F103_inclinometer  - 4G - V3.3.1 (6070000::V6.7::.\ARMCLANG)
  device: STM32U073CCUx STMicroelectronics
  pack: Keil.STM32U0xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20009FFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M0+") TZ
  output: STM32U073_inclinometer  - 4G - V3_3_1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U073xx
  c misc: -include .cmsis/include/stm32u0xx_hal_compat.h
  c include: ../Core/Inc;../Drivers/STM32U0xx_HAL_Driver/Inc;../Drivers/STM32U0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32U0xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  group Application/MDK-ARM
    ./: startup_stm32u073xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c i2c.c usart.c rtc.c spi.c stm32u0xx_it.c stm32u0xx_hal_msp.c ICM42688P.c bq27220.c iic.c lte.c app_config.c app.c config_cli.c
  group Drivers/STM32U0xx_HAL_Driver
    ../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal_adc.c stm32u0xx_hal_adc_ex.c stm32u0xx_ll_adc.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal_cortex.c stm32u0xx_hal.c stm32u0xx_hal_exti.c stm32u0xx_hal_i2c.c stm32u0xx_hal_i2c_ex.c stm32u0xx_ll_i2c.c stm32u0xx_hal_uart.c stm32u0xx_hal_uart_ex.c stm32u0xx_hal_rtc.c stm32u0xx_hal_rtc_ex.c stm32u0xx_hal_spi.c stm32u0xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u0xx.c
software components: CMSIS:CORE 5.6.0
